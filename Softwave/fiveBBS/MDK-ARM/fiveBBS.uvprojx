# Keil uVision project fiveBBS.uvprojx, settings and files
target fiveBBS (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: fiveBBS +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../Middlewares/easylogger/inc;../Debug;../Middlewares/SEEGGER/Config;../Middlewares/SEEGGER/RTT;../BSP/Button;../BSP/ili9341_LCD;../BSP/LED;../Middlewares/Function;..\BSP\Platform_Interface\Button;..\APP_Platform\User_Init;..\OS_Platform\OS_Wrapper\inc;..\OS_Platform\OS_Implementation\FreeRTOS\inc;..\Middlewares\os_adapter\inc;..\APP_Platform\User_Init\Platform_IO_Register;..\APP_Platform\User_Init\User_Task_Config;..\MCU_Platform\MCU_Core_GPIO;..\MCU_Platform\MCU_Core_IIC;..\MCU_Platform\MCU_Core_SPI;..\MCU_Platform\Protocol_adaper_Port
  asm include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;..\BSP;..\SYSTEM
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c adc.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_tim.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
  group BSP
    ../BSP/LED/: bsp_LED.c
    ../BSP/Button/: bsp_multi_button.c
  group Middlewares/Easylogger
    ../Middlewares/easylogger/src/: elog.c elog_async.c elog_buf.c elog_utils.c
    ../Debug/: debug.c
    ../Middlewares/easylogger/port/: elog_port.c
    ../Middlewares/SEEGGER/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group Middlewares/Function
    ../Middlewares/Function/: circular_buffer.c
  group BSP/Platform_Interface
    ../BSP/Platform_Interface/Button/: bsp_adaper_port_button.c
  group APP/User_App
    ../APP_Platform/User_Init/: user_init.c
    ../APP_Platform/User_Init/User_Task_Config/: user_task_reso_config.c
    ../APP_Platform/User_Init/Platform_IO_Register/: user_periph_setup.c
  group OS_Platform/OS_Wrapper
    ../OS_Platform/OS_Wrapper/src/: osal_heap.c osal_mutex.c osal_queue.c osal_sema.c osal_task.c osal_timer.c
  group OS_Platform/OS_Implementation
    ../OS_Platform/OS_Implementation/FreeRTOS/src/: os_impl_heap.c os_impl_mutex.c os_impl_queue.c os_impl_sema.c os_impl_task.c os_impl_timer.c
  group MCU_Platform/Device_adaper_Port
    ../MCU_Platform/MCU_Core_GPIO/: gpio_port.c
    ../MCU_Platform/MCU_Core_IIC/: i2c_port.c
    ../MCU_Platform/MCU_Core_SPI/: spi_port.c
    ../MCU_Platform/Protocol_adaper_Port/: Protocol_adaper_Port.c
software components: CMSIS:CORE 4.3.0
